FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://thing-revived-uhid.cfg"
